# Keil uVision project haut-parleurs.uvprojx, settings and files
target LPC1768 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: code sonore
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: haut-parleur.c main_exemple.c
software components: CMSIS:CORE 6.0.0, CMSIS Driver:USART 2.13.0, Device:GPDMA 1.4.0, Device:PIN 1.0.0, Device:Startup 1.0.0
